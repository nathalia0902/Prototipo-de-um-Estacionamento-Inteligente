## projeto/Config.in
```kconfig
config BR2_PACKAGE_PROJETO
    bool "projeto"
    help
        Aplicativo projeto.
```
